.title KiCad schematic
.include "bipmod.lib"
Q8 Net-_Q18-Pad1_ Net-_Q10-Pad1_ Vcc PN
Q11 Net-_Q10-Pad1_ Net-_Q10-Pad1_ Vcc PN
Q5 Net-_Q19-Pad1_ Net-_Q1-Pad1_ Vcc PN
Q1 Net-_Q1-Pad1_ Net-_Q1-Pad1_ Vcc PN
Q2 Net-_Q1-Pad1_ Threas Net-_Q2-Pad3_ NP
Q6 Net-_Q1-Pad1_ Net-_Q2-Pad3_ Net-_Q10-Pad3_ NP
Q10 Net-_Q10-Pad1_ Net-_Q10-Pad2_ Net-_Q10-Pad3_ NP
Q12 Net-_Q10-Pad1_ Vctrl Net-_Q10-Pad2_ NP
V1 Vcc GND 15
C2 Vctrl GND 10n
Q13 Net-_Q13-Pad1_ Net-_Q13-Pad2_ GND NP
R14 Threas Dis 20k
V3 Reset GND pulse(0 15 0 1u 1u 5m 10m)
C1 Threas GND 10n
Q4 Dis Net-_Q3-Pad1_ GND NP
R1 Net-_Q10-Pad3_ GND 10k
Q9 Net-_Q13-Pad1_ Net-_Q7-Pad3_ Net-_Q15-Pad1_ PN
Q7 GND Threas Net-_Q7-Pad3_ PN
Q3 Net-_Q3-Pad1_ Reset Net-_Q21-Pad1_ PN
Q20 Net-_Q15-Pad2_ Net-_Q15-Pad2_ Vcc PN
Q23 Net-_Q15-Pad2_ Net-_Q15-Pad2_ Vcc PN
R2 Vcc Net-_Q15-Pad3_ 1k
Q15 Net-_Q15-Pad1_ Net-_Q15-Pad2_ Net-_Q15-Pad3_ PN
R6 Net-_Q15-Pad2_ Net-_Q21-Pad1_ 7.5k
R3 Vcc Vctrl 5k
R10 Net-_Q28-Pad3_ GND 3.3k
R11 Net-_Q32-Pad2_ Net-_Q28-Pad3_ 120
Q32 out Net-_Q32-Pad2_ GND NP
Q30 GND Net-_Q28-Pad1_ out PN
R12 Net-_Q29-Pad3_ out 3.9k
R8 Vcc Net-_Q28-Pad1_ 6.2k
Q29 Vcc Net-_Q28-Pad1_ Net-_Q29-Pad3_ NP
Q31 Vcc Net-_Q29-Pad3_ out NP
Q25 Net-_Q25-Pad1_ Net-_Q15-Pad2_ Vcc PN
Q19 Net-_Q19-Pad1_ Net-_Q18-Pad1_ GND NP
R13 Vcc Dis 20k
R5 Net-_Q17-Pad2_ GND 5k
R4 Vctrl Net-_Q17-Pad2_ 5k
Q16 Net-_Q13-Pad2_ Net-_Q16-Pad2_ Net-_Q15-Pad1_ PN
Q14 Net-_Q13-Pad2_ Net-_Q13-Pad2_ GND NP
Q17 GND Net-_Q17-Pad2_ Net-_Q16-Pad2_ PN
Q18 Net-_Q18-Pad1_ Net-_Q18-Pad1_ GND NP
Q24 Net-_Q24-Pad1_ Net-_Q21-Pad3_ GND NP
R9 Net-_Q28-Pad3_ Net-_Q3-Pad1_ 100
R7 Net-_Q25-Pad1_ Net-_Q21-Pad3_ 4.7k
Q22 Net-_Q21-Pad3_ Net-_Q13-Pad1_ GND NP
Q21 Net-_Q21-Pad1_ Net-_Q19-Pad1_ Net-_Q21-Pad3_ NP
Q27 Net-_Q21-Pad1_ Net-_Q21-Pad1_ Net-_Q24-Pad1_ NP
Q26 Net-_Q25-Pad1_ Net-_Q24-Pad1_ GND NP
Q28 Net-_Q28-Pad1_ Net-_Q25-Pad1_ Net-_Q28-Pad3_ NP
.tran 1u 30m
.end
